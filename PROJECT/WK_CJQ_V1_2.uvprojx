# Keil uVision project WK_CJQ_V1_2.uvprojx, settings and files
target WK_CJQ_V1_2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WK_CJQ_V1_2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\SOFTWARE\CMD;..\SOFTWARE\collect;..\SOFTWARE\CRC8_16;..\SOFTWARE\DATA_MAP;..\SOFTWARE\IRQ;..\SOFTWARE\KEY;..\SOFTWARE\LED;..\SOFTWARE\PM2.5;..\SOFTWARE\RF;..\SOFTWARE\SHT21;..\SOFTWARE\SPG30;..\SOFTWARE\STM32FLASH;..\SOFTWARE\TVOC;..\SOFTWARE\WDG;..\STM32LIB\inc;..\SYSTEM;..\USER
  memory RVCT4: ROM 0x8002800 size 0xd800
  memory RVCT9: RAM 0x20000400 size 0x4c00
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group STM32LIB
    ../STM32LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group SOFTWARE
    ../SOFTWARE/CMD/: deal.c
    ../SOFTWARE/collect/: collect.c
    ../SOFTWARE/CRC8_16/: crc8_16.c
    ../SOFTWARE/DATA_MAP/: data_map.c
    ../SOFTWARE/IRQ/: interruptdef.c
    ../SOFTWARE/KEY/: key.c
    ../SOFTWARE/LED/: led.c light.c
    ../SOFTWARE/PM2.5/: usart3.c
    ../SOFTWARE/RF/: drv_AS62.c usart1.c
    ../SOFTWARE/SHT21/: myiic.c sht21.c
    ../SOFTWARE/SPG30/: sensirion_common.c sensirion_sw_i2c.c sgp30.c sgp30_featureset.c
    ../SOFTWARE/STM32FLASH/: flash.c
    ../SOFTWARE/TVOC/: data.c kqm2801A.c
    ../SOFTWARE/WDG/: wdg.c
